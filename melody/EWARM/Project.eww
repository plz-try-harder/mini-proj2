<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\melody.ewp</path>
  </project>
  <batchBuild />
</workspace>
